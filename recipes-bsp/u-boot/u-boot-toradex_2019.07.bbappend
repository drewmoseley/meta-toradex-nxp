require recipes-bsp/u-boot/u-boot-toradex-initial-env.inc
