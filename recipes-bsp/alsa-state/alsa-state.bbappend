FILESEXTRAPATHS_prepend_toradex := "${THISDIR}/alsa-state/:"

#make this machine specific, as we have different codecs with different settings
PACKAGE_ARCH_toradex = "${MACHINE_ARCH}"
